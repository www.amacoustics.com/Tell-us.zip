Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Acoustics_Akustikmiljo_Tell-Us-by-AM-Acoustics.ifc
Time: 2020-01-15T09:34:05
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Tell-Us by AM Acoustics
ePset_BIMobjectScript - Bracket: With; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Tell-Us by AM Acoustics; SKU (BO_prodsku): tell-us; ManufacturName (BO_Manufac): Akustikmiljö; ProductFamily (BO_prodfam): Furniture; ProductGroup (BO_prodgroup): Wall and Ceiling Acoustics; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; EditionNumber (BO_edinum): 1; Width (BO_width): 1600; Height (BO_height): 1200; Depth (BO_depth): 50; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/akustikmiljo/product/tell-us; ProductDataUrl (BO_prodaturl): bimobject.com/akustikmiljo/product/tell-us; ProductUrl (BO_producturl): https://www.gotessons.com/en/wall-and-ceiling-acoustics/tell-us-acoustic-world-map; ProductCertification (BO_prodcert): https://www.gotessons.com/en/quality-and-environment/; TechnicalDescription (BO_techcert): https://www.gotessons.com/storage/0DB6A2E4FCF120A6325904FE3E5684AD7E6E59A36508E795C3813979F5419289/b57505dbf4c647c0be444cc59aee8b01/pdf/media/b6c7f1c4d70d40e5849fb3a909f8f669/160120-_ritning.pdf; MaterialMain (BO_mainmat): Polyester; MaterialSecondary (BO_secmat): Polyester; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Acoustics; BimObjectCategoryCode (BO_bocat_code): furniture-acoustics; IfcClassification (BO_ifcclas): Furniture; UnspcCode (BO_unspc): 56; Uniclass2015Code (BO_uniclass2015_code): EF_40_30; Uniclass2015Description (BO_uniclass2015_desc): Furnishings; UniFormat2Code (BO_uniformat2_code): E20; UniFormat2Description (BO_uniformat2_name): FURNISHINGS; RegionEurope (BO_europe): SE
